# Keil uVision project Advanced Clock.uvprojx, settings and files
target Advanced clock (6190000::V6.19::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Advanced_clock
  c flags: Optim=4 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=2
  c define: CLOCK_SETUP=1
  c misc: -Wno-gnu-binary-literal -Wno-missing-prototypes -Wno-missing-noreturn -Wno-sign-conversion -Wno-declaration-after-statement
  c include: ./inc;.\queue;.\uart0;.\servos;.\pc_comm
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group src
    ./src/: main.c
  group UART
    ./uart0/: uart0.c uart0.h
  group Queue
    ./queue/: queue.c queue.h
  group Pc_comm
    ./pc_comm/: pc_comm.c pc_comm.h
  group Servos
    ./servos/: servoControl.c servoControl.h ServoConfig.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.5.0
